# Keil uVision project WKT_INT.uvproj, settings and files
target WDT (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: WKT_INT +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include;..\..\Common
  group Source
    ./Code/: WKT_INT.c
  group Common
    ../../Common/: Delay.c
  group Startup
    ../../Startup/: STARTUP_N76E003beta.A51

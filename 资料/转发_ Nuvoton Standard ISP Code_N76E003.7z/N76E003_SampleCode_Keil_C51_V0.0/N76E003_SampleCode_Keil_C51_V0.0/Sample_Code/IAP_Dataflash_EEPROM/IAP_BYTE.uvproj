# Keil uVision project IAP_BYTE.uvproj, settings and files
target IAP_BYTE (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: IAP_BYTE +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source Group 1
    ./Code/: IAP_BYTE.c
  group Startup
    ../../Startup/: STARTUP_N76E003beta.A51

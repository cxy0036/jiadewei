# Keil uVision project SPI_Slave_Polling.uvproj, settings and files
target SPI_POL_S (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: Slave_p +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_221184
  c include: ..\..\..\..\Include
  group Source
    ./Code/: SPI_Slave_Po.c
  group Common
    ../../../../Common/: Common.c Delay.c Version.c
  group Startup
    ../../../../Startup/: STARTUP.A51

# Keil uVision project UID.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: UID_check +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Common;..\..\Include
  group Source Group 1
    ./Code/: UID_check.C
  group Startup
    ../../Startup/: STARTUP_N76E003beta.A51
  group Common
    ../../Common/: Delay.c

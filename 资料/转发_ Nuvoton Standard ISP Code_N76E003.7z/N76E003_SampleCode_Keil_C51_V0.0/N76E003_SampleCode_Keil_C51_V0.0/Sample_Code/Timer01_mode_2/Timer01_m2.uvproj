# Keil uVision project Timer01_m2.uvproj, settings and files
target Timer01_M2 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Timer01 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source
    ./Code/: Timer01_M2.c
  group Startup
    ../../Startup/: STARTUP_N76E003beta.A51

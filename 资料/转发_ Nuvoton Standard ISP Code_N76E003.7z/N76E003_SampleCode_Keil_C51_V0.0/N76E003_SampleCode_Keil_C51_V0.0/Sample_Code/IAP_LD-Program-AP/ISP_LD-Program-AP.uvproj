# Keil uVision project ISP_LD-Program-AP.uvproj, settings and files
target ISP_LD-AP (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: ISP_LD +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source
    ./Code/: ISP_LD-AP.c
  group Common
    ../../Common/: Delay.c
  group Startup
    ../../Startup/: STARTUP_N76E003beta.A51

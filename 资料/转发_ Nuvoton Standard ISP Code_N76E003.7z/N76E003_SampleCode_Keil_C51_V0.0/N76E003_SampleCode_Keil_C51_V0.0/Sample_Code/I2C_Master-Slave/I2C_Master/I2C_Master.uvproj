# Keil uVision project I2C_Master.uvproj, settings and files
target I2C_Master (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: I2C_M +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\Common;..\..\..\Include
  group Source
    ./Code/: I2C_M.c
  group Common
    ../../../Common/: Delay.c
    ./Code/: bl-291-16.04.16.c
  group Startup
    ../../../Startup/: STARTUP.A51

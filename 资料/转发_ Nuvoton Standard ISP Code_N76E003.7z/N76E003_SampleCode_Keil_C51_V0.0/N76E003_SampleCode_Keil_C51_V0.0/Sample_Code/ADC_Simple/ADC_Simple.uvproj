# Keil uVision project ADC_Simple.uvproj, settings and files
target ADC (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: ADC_Simple +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source Group 1
    ./Code/: ADC.C
  group Common
    ../../Common/: Common.c Delay.c
  group Startup
    ../../Startup/: STARTUP_N76E003beta.A51

# Keil uVision project FSYS_SEL.uvproj, settings and files
target CLK_OUT (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: FSYS_SEL +hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source
    ./Code/: Fsys_SEL.c
  group Common
    ../../Common/: Delay.c Common.c
  group Startup
    ../../Startup/: STARTUP_N76E003beta.A51

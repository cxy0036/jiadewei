# Keil uVision project adc.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: adc +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\include
  group Source Group 1
    ./source code/: Main.c INT1.C Timer2.c
  group common
    ./common/: Common.c Delay.c
  group startup
    ./startup/: STARTUP_N76E003beta.A51

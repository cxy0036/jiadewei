# Keil uVision project Infrared_demo.uvproj, settings and files
target Infrared_demo (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Infrared_demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\include;.\common;.\module
  asm include: .\startup
  group demo
    ./demo/: MAIN.C
  group module
    ./module/: bluetooth.c adc.c gpio.c time0.c
  group include
    ./include/: Codingformat_Define.h Define.h Function_define.h N76E003.h SFR_Macro.h N76E003_GPIO.h
  group startup
    ./startup/: STARTUP_N76E003beta.A51
  group common
    ./common/: Delay.c

# Keil uVision project demo.uvproj, settings and files
target demo (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\src;.\include
  asm include: .\Startup
  group src
    ./src/: Common.c Delay.c demo.c sysInit.c adc.c bluetooth.c time0.c
  group include
    ./include/: Common.h Define.h Delay.h Function_define.h N76E003.h SFR_Macro.h
  group startup
    ./Startup/: STARTUP_N76E003beta.A51

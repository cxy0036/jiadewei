# Keil uVision project AIOS_mini54zde.uvproj, settings and files
target AIOS_MINI54ZDE (5050041::V5.05 (build 41)::ARMCC)
  device: (Generic) Mini51 Series Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x7FF) CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: AIOS_mini54zde
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\AIOS\Kernel;.\AIOS\CPU\ARM\KEIL\Cortex_M0;.\CMSIS\Include;.\Device\Nuvoton\Mini51Series\Include;.\User;.\StdDriver\inc;.\Device\Nuvoton\Mini51Series\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x4000
  group AIOS
    ./AIOS/CPU/ARM/KEIL/Cortex_M0/: FitCPU.c
    ./AIOS/Kernel/: OSList.c OSMemory.c OSMsgQ.c OSMutex.c OSSem.c OSTask.c OSTimer.c
  group CMSIS
    ./Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ./Library/Device/Nuvoton/Mini51Series/Source/ARM/: startup_Mini51Series.s
  group Driver
    ./StdDriver/src/: acmp.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c sys.c spi.c timer.c uart.c wdt.c
  group User
    ./User/: main.c task.c NTP8230.c ir.c

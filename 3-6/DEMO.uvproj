# Keil uVision project DEMO.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: DEMO
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\include
  asm include: .\startup
  group DEMO
    ./demo/: Recive_demo.c
  group INCLUDE
    ./include/: Common.h Define.h Delay.h Function_define.h N76E003.h SFR_Macro.h ex-int1.h Codingformat_Define.h
  group COMMON
    ./common/: Common.c Delay.c
  group STARTUP
    ./startup/: STARTUP_N76E003beta.A51
  group MODULE
    ./module/: ex-int1.c time0.c
